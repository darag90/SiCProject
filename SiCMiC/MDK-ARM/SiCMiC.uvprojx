# Keil uVision project SiCMiC.uvprojx, settings and files
target SiCMiC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L053C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: SiCMiC
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32L0xx_HAL_Driver/Inc;   ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Include;   ../Drivers/CMSIS/Device/ST/STM32L0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: usart.c gpio.c i2c.c dac.c usart.c main.c adc.c stm32l0xx_hal_msp.c iwdg.c stm32l0xx_it.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_dma.c stm32l0xx_hal_rcc.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ./: 
    ..//Src/: system_stm32l0xx.c
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
software components: CMSIS:CORE 4.1.0
